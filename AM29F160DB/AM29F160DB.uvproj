# Keil uVision project AM29F160DB.uvproj, settings and files
target AM29F160DB (ARM-ADS)
  device: AT91M55800A Atmel
  cpu: IRAM(0-0x1FFF) CLOCK(33000000) CPUTYPE(ARM7TDMI)
  output: AM29F160DB
  AfterMake: cmd.exe /C copy AM29F160DB.axf ..\AM29F160DB.FLX
  c flags: Optim=3
  memory RVCT9: RAM 0x0 size 0x2000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
